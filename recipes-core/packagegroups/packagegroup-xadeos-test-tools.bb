SUMMARY = "XaDe OS test tool package"

PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = "stress-ng"
