require XaDeOS.bb
IMAGE_INSTALL += "packagegroup-bernardos-debug"
IMAGE_FEATURES += "dev-pkgs"